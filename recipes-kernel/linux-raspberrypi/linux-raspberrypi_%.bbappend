
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://cleanup.cfg"
